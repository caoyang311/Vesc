# Keil uVision project PMSM_Motor.uvprojx, settings and files
target MOTOR (5060750::V5.06 update 6 (build 750)::.\ARMCC)
  device: STM32F407IG STMicroelectronics
  pack: Keil.STM32F4xx_DFP.3.0.0
  cpu: IRAM(0x20000000,0x20000) IRAM2(0x10000000,0x10000) IROM(0x08000000,0x100000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: PMSM_Motor +hex
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: STM32F40_41xxx,USE_STDPERIPH_DRIVER,__TARGET_FPU_VFP,ARM_MATH_CM4,__CC_ARM,__FPU_PRESENT=1U
  c include: ..\App\inc;..\Driver\inc;..\System;..\Fwlib\inc;..\Core;..\DSP\inc
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group App
    ../App/src/: main.c key.c motor.c led.c debug.c at24c02.c abs_encoder.c foc.c pid.c
  group Driver
    ../Driver/src/: adc.c timer.c uart.c gpio.c dac.c i2c.c
  group FwLib
    ../FWLIB/src/: misc.c stm32f4xx_gpio.c stm32f4xx_rcc.c stm32f4xx_syscfg.c stm32f4xx_tim.c stm32f4xx_usart.c stm32f4xx_adc.c stm32f4xx_dma.c
    ../Fwlib/src/: stm32f4xx_dac.c stm32f4xx_exti.c stm32f4xx_i2c.c
  group System
    ../System/: stm32f4xx_it.c system_stm32f4xx.c
  group Core
    ../CORE/: startup_stm32f40_41xxx.s
  group DSP
    ../DSP/src/: arm_cos_f32.c arm_sin_f32.c arm_cortexM4lf_math.lib arm_cfft_f32.c arm_cmplx_mag_f32.c
