/******************************************************************************
 * 文件: Id_2D_Map.c
 * 功能: MTPV MAP - Id 二维表 + (转矩,转速)双线性查表; 含 Rs/Psi 温补、Ld/Lq 饱和表
 * 创建日期: 2026-06-22
 * 修改日期: 2026-10-10
 * 修改内容: 删除 RAM 镜像机制: 表去 const 直接可写(上电由 C 初始值装载),
 *           量程/间隔独立变量(0x20/03 直接读写); 查表/0x21/重算操作原数组
 *           0x21 值表(02/03)改紧致编址(idx=行*当前转速点数+列), 矩阵改尺寸后连续读写不再错位
 *           Rs/磁链/Ld/Lq 表点数运行时可写(0x20/03 idx3/idx4, 有效尺寸窗口 3..上限,
 *           槽位/紧致编址/温补与饱和查表按有效尺寸)
 * 修改人: rui.zhang
 ******************************************************************************/

/* 维度[转矩][转速]; 转矩 0~50Nm 步长1.6; 转速 0~8000rpm 步长258
 * 电机参数: Rs=8.000mOhm Ld=127uH Lq=280uH psi=16.6mWb */

#include <stdint.h>

#define TORQUE_POINTS    32
#define SPEED_POINTS     32
#include "MTPV_MAP.h"   /* 表尺寸与读写接口声明 */

/* 转矩查找表 (Nm) — 仅在 Id_2D_Map.c 中定义 */
float Torque_Table[TORQUE_POINTS] = {
0.0000f, 1.6129f, 3.2258f, 4.8387f, 6.4516f, 8.0645f, 9.6774f, 11.2903f,
    12.9032f, 14.5161f, 16.1290f, 17.7419f, 19.3548f, 20.9677f, 22.5806f, 24.1935f,
    25.8065f, 27.4194f, 29.0323f, 30.6452f, 32.2581f, 33.8710f, 35.4839f, 37.0968f,
    38.7097f, 40.3226f, 41.9355f, 43.5484f, 45.1613f, 46.7742f, 48.3871f, 50.0000f
};

/* 转速查找表 (rpm) — 仅在 Id_2D_Map.c 中定义 */
float Speed_Table[SPEED_POINTS] = {
0.0f, 258.1f, 516.1f, 774.2f, 1032.3f, 1290.3f, 1548.4f, 1806.5f,
    2064.5f, 2322.6f, 2580.6f, 2838.7f, 3096.8f, 3354.8f, 3612.9f, 3871.0f,
    4129.0f, 4387.1f, 4645.2f, 4903.2f, 5161.3f, 5419.4f, 5677.4f, 5935.5f,
    6193.5f, 6451.6f, 6709.7f, 6967.7f, 7225.8f, 7483.9f, 7741.9f, 8000.0f
};

/* Id MAP 表 (A) - [转矩索引][转速索引] */
float Id_Map[TORQUE_POINTS][SPEED_POINTS] = {
    {0.0000f, 0.0000f, 0.0000f, 0.0000f, 0.0000f, 0.0000f, 0.0000f, 0.0000f, 
     0.0000f, 0.0000f, 0.0000f, 0.0000f, 0.0000f, 0.0000f, 0.0000f, 0.0000f, 
     0.0000f, 0.0000f, 0.0000f, 0.0000f, 0.0000f, 0.0000f, 0.0000f, 0.0000f, 
     0.0000f, 0.0000f, 0.0000f, 0.0000f, 0.0000f, 0.0000f, 0.0000f, 0.0000f},
    {-2.0534f, -2.0534f, -2.0534f, -2.0534f, -2.0534f, -2.0534f, -2.0534f, -2.0534f, 
     -2.0534f, -2.0534f, -2.0534f, -2.0534f, -2.0534f, -2.0534f, -2.0534f, -2.0534f, 
     -2.0534f, -2.0534f, -2.0534f, -2.0534f, -2.0534f, -2.0534f, -2.0534f, -130.7390f, 
     -130.7390f, -130.7390f, -130.7390f, -130.7390f, -130.7390f, -130.7390f, -130.7390f, -130.7390f},
    {-7.7325f, -7.7325f, -7.7325f, -7.7325f, -7.7325f, -7.7325f, -7.7325f, -7.7325f, 
     -7.7325f, -7.7325f, -7.7325f, -7.7325f, -7.7325f, -7.7325f, -7.7325f, -7.7325f, 
     -7.7325f, -7.7325f, -7.7325f, -7.7325f, -7.7325f, -7.7325f, -130.7390f, -130.7390f, 
     -130.7390f, -130.7390f, -130.7390f, -130.7390f, -130.7390f, -130.7390f, -130.7390f, -130.7390f},
    {-14.6656f, -14.6656f, -14.6656f, -14.6656f, -14.6656f, -14.6656f, -14.6656f, -14.6656f, 
     -14.6656f, -14.6656f, -14.6656f, -14.6656f, -14.6656f, -14.6656f, -14.6656f, -14.6656f, 
     -14.6656f, -14.6656f, -14.6656f, -14.6656f, -14.6656f, -130.7390f, -130.7390f, -130.7390f, 
     -130.7390f, -130.7390f, -130.7390f, -130.7390f, -135.7390f, -140.7390f, -145.7390f, -150.7390f},
    {-22.3652f, -22.3652f, -22.3652f, -22.3652f, -22.3652f, -22.3652f, -22.3652f, -22.3652f, 
     -22.3652f, -22.3652f, -22.3652f, -22.3652f, -22.3652f, -22.3652f, -22.3652f, -22.3652f, 
     -22.3652f, -22.3652f, -22.3652f, -130.7390f, -130.7390f, -135.7390f, -145.7390f, -150.7390f, 
     -160.7390f, -165.7390f, -175.7390f, -190.7390f, -599.9411f, -599.9411f, -599.9411f, -599.9411f},
    {-29.2721f, -29.2721f, -29.2721f, -29.2721f, -29.2721f, -29.2721f, -29.2721f, -29.2721f, 
     -29.2721f, -29.2721f, -29.2721f, -29.2721f, -29.2721f, -29.2721f, -29.2721f, -29.2721f, 
     -29.2721f, -29.2721f, -150.7390f, -165.7390f, -175.7390f, -190.7390f, -599.8695f, -599.8695f, 
     -599.8695f, -599.8695f, -599.8695f, -599.8695f, -599.8695f, -599.8695f, -599.8695f, -599.8695f},
    {-36.7319f, -36.7319f, -36.7319f, -36.7319f, -36.7319f, -36.7319f, -36.7319f, -36.7319f, 
     -36.7319f, -36.7319f, -36.7319f, -36.7319f, -36.7319f, -36.7319f, -36.7319f, -36.7319f, 
     -36.7319f, -190.7390f, -220.7390f, -599.7704f, -599.7704f, -599.7704f, -599.7704f, -599.7704f, 
     -599.7704f, -599.7704f, -599.7704f, -599.7704f, -599.7704f, -599.7704f, -599.7704f, -599.7704f},
    {-40.8444f, -40.8444f, -40.8444f, -40.8444f, -40.8444f, -40.8444f, -40.8444f, -40.8444f, 
     -40.8444f, -40.8444f, -40.8444f, -40.8444f, -40.8444f, -40.8444f, -40.8444f, -215.7390f, 
     -599.7683f, -599.7683f, -599.7683f, -599.7683f, -599.7683f, -599.7683f, -599.7683f, -599.7683f, 
     -599.7683f, -599.7683f, -599.7683f, -599.7683f, -599.7683f, -599.7683f, -599.7683f, -599.7683f},
    {-49.5919f, -49.5919f, -49.5919f, -49.5919f, -49.5919f, -49.5919f, -49.5919f, -49.5919f, 
     -49.5919f, -49.5919f, -49.5919f, -49.5919f, -49.5919f, -49.5919f, -49.5919f, -599.6412f, 
     -599.6412f, -599.6412f, -599.6412f, -599.6412f, -599.6412f, -599.6412f, -599.6412f, -599.6412f, 
     -599.6412f, -599.6412f, -599.6412f, -599.6412f, -599.6412f, -599.6412f, -599.6412f, -599.6412f},
    {-57.6474f, -57.6474f, -57.6474f, -57.6474f, -57.6474f, -57.6474f, -57.6474f, -57.6474f, 
     -57.6474f, -57.6474f, -57.6474f, -57.6474f, -57.6474f, -57.6474f, -599.6372f, -599.6372f, 
     -599.6372f, -599.6372f, -599.6372f, -599.6372f, -599.6372f, -599.6372f, -599.6372f, -599.6372f, 
     -599.6372f, -599.6372f, -599.6372f, -599.6372f, -599.6372f, -599.6372f, -599.6372f, -599.6372f},
    {-62.5313f, -62.5313f, -62.5313f, -62.5313f, -62.5313f, -62.5313f, -62.5313f, -62.5313f, 
     -62.5313f, -62.5313f, -62.5313f, -62.5313f, -62.5313f, -599.4804f, -599.4804f, -599.4804f, 
     -599.4804f, -599.4804f, -599.4804f, -599.4804f, -599.4804f, -599.4804f, -599.4804f, -599.4804f, 
     -599.4804f, -599.4804f, -599.4804f, -599.4804f, -599.4804f, -599.4804f, -599.4804f, -599.4804f},
    {-66.7786f, -66.7786f, -66.7786f, -66.7786f, -66.7786f, -66.7786f, -66.7786f, -66.7786f, 
     -66.7786f, -66.7786f, -66.7786f, -66.7786f, -599.4756f, -599.4756f, -599.4756f, -599.4756f, 
     -599.4756f, -599.4756f, -599.4756f, -599.4756f, -599.4756f, -599.4756f, -599.4756f, -599.4756f, 
     -599.4756f, -599.4756f, -599.4756f, -599.4756f, -599.4756f, -599.4756f, -599.4756f, -599.4756f},
    {-71.0945f, -71.0945f, -71.0945f, -71.0945f, -71.0945f, -71.0945f, -71.0945f, -71.0945f, 
     -71.0945f, -71.0945f, -71.0945f, -71.0945f, -599.2917f, -599.2917f, -599.2917f, -599.2917f, 
     -599.2917f, -599.2917f, -599.2917f, -599.2917f, -599.2917f, -599.2917f, -599.2917f, -599.2917f, 
     -599.2917f, -599.2917f, -599.2917f, -599.2917f, -599.2917f, -599.2917f, -599.2917f, -599.2917f},
    {-75.2665f, -75.2665f, -75.2665f, -75.2665f, -75.2665f, -75.2665f, -75.2665f, -75.2665f, 
     -75.2665f, -75.2665f, -75.2665f, -599.0797f, -599.0797f, -599.0797f, -599.0797f, -599.0797f, 
     -599.0797f, -599.0797f, -599.0797f, -599.0797f, -599.0797f, -599.0797f, -599.0797f, -599.0797f, 
     -599.0797f, -599.0797f, -599.0797f, -599.0797f, -599.0797f, -599.0797f, -599.0797f, -599.0797f},
    {-79.3081f, -79.3081f, -79.3081f, -79.3081f, -79.3081f, -79.3081f, -79.3081f, -79.3081f, 
     -79.3081f, -79.3081f, -79.3081f, -599.0763f, -599.0763f, -599.0763f, -599.0763f, -599.0763f, 
     -599.0763f, -599.0763f, -599.0763f, -599.0763f, -599.0763f, -599.0763f, -599.0763f, -599.0763f, 
     -599.0763f, -599.0763f, -599.0763f, -599.0763f, -599.0763f, -599.0763f, -599.0763f, -599.0763f},
    {-89.6680f, -89.6680f, -89.6680f, -89.6680f, -89.6680f, -89.6680f, -89.6680f, -89.6680f, 
     -89.6680f, -89.6680f, -89.6680f, -598.6102f, -598.6102f, -598.6102f, -598.6102f, -598.6102f, 
     -598.6102f, -598.6102f, -598.6102f, -598.6102f, -598.6102f, -598.6102f, -598.6102f, -598.6102f, 
     -598.6102f, -598.6102f, -598.6102f, -598.6102f, -598.6102f, -598.6102f, -598.6102f, -598.6102f},
    {-99.8061f, -99.8061f, -99.8061f, -99.8061f, -99.8061f, -99.8061f, -99.8061f, -99.8061f, 
     -99.8061f, -99.8061f, -597.3772f, -597.3772f, -597.3772f, -597.3772f, -597.3772f, -597.3772f, 
     -597.3772f, -597.3772f, -597.3772f, -597.3772f, -597.3772f, -597.3772f, -597.3772f, -597.3772f, 
     -597.3772f, -597.3772f, -597.3772f, -597.3772f, -597.3772f, -597.3772f, -597.3772f, -597.3772f},
    {-103.9644f, -103.9644f, -103.9644f, -103.9644f, -103.9644f, -103.9644f, -103.9644f, -103.9644f, 
     -103.9644f, -103.9644f, -595.7683f, -595.7683f, -595.7683f, -595.7683f, -595.7683f, -595.7683f, 
     -595.7683f, -595.7683f, -595.7683f, -595.7683f, -595.7683f, -595.7683f, -595.7683f, -595.7683f, 
     -595.7683f, -595.7683f, -595.7683f, -595.7683f, -595.7683f, -595.7683f, -595.7683f, -595.7683f},
    {-108.0160f, -108.0160f, -108.0160f, -108.0160f, -108.0160f, -108.0160f, -108.0160f, -108.0160f, 
     -108.0160f, -108.0160f, -593.7941f, -593.7941f, -593.7941f, -593.7941f, -593.7941f, -593.7941f, 
     -593.7941f, -593.7941f, -593.7941f, -593.7941f, -593.7941f, -593.7941f, -593.7941f, -593.7941f, 
     -593.7941f, -593.7941f, -593.7941f, -593.7941f, -593.7941f, -593.7941f, -593.7941f, -593.7941f},
    {-111.9688f, -111.9688f, -111.9688f, -111.9688f, -111.9688f, -111.9688f, -111.9688f, -111.9688f, 
     -111.9688f, -591.4690f, -591.4690f, -591.4690f, -591.4690f, -591.4690f, -591.4690f, -591.4690f, 
     -591.4690f, -591.4690f, -591.4690f, -591.4690f, -591.4690f, -591.4690f, -591.4690f, -591.4690f, 
     -591.4690f, -591.4690f, -591.4690f, -591.4690f, -591.4690f, -591.4690f, -591.4690f, -591.4690f},
    {-115.8296f, -115.8296f, -115.8296f, -115.8296f, -115.8296f, -115.8296f, -115.8296f, -115.8296f, 
     -115.8296f, -588.8093f, -588.8093f, -588.8093f, -588.8093f, -588.8093f, -588.8093f, -588.8093f, 
     -588.8093f, -588.8093f, -588.8093f, -588.8093f, -588.8093f, -588.8093f, -588.8093f, -588.8093f, 
     -588.8093f, -588.8093f, -588.8093f, -588.8093f, -588.8093f, -588.8093f, -588.8093f, -588.8093f},
    {-119.6046f, -119.6046f, -119.6046f, -119.6046f, -119.6046f, -119.6046f, -119.6046f, -119.6046f, 
     -119.6046f, -585.8333f, -585.8333f, -585.8333f, -585.8333f, -585.8333f, -585.8333f, -585.8333f, 
     -585.8333f, -585.8333f, -585.8333f, -585.8333f, -585.8333f, -585.8333f, -585.8333f, -585.8333f, 
     -585.8333f, -585.8333f, -585.8333f, -585.8333f, -585.8333f, -585.8333f, -585.8333f, -585.8333f},
    {-123.2993f, -123.2993f, -123.2993f, -123.2993f, -123.2993f, -123.2993f, -123.2993f, -123.2993f, 
     -123.2993f, -582.5623f, -582.5623f, -582.5623f, -582.5623f, -582.5623f, -582.5623f, -582.5623f, 
     -582.5623f, -582.5623f, -582.5623f, -582.5623f, -582.5623f, -582.5623f, -582.5623f, -582.5623f, 
     -582.5623f, -582.5623f, -582.5623f, -582.5623f, -582.5623f, -582.5623f, -582.5623f, -582.5623f},
    {-126.9185f, -126.9185f, -126.9185f, -126.9185f, -126.9185f, -126.9185f, -126.9185f, -126.9185f, 
     -126.9185f, -579.0192f, -579.0192f, -579.0192f, -579.0192f, -579.0192f, -579.0192f, -579.0192f, 
     -579.0192f, -579.0192f, -579.0192f, -579.0192f, -579.0192f, -579.0192f, -579.0192f, -579.0192f, 
     -579.0192f, -579.0192f, -579.0192f, -579.0192f, -579.0192f, -579.0192f, -579.0192f, -579.0192f},
    {-130.4668f, -130.4668f, -130.4668f, -130.4668f, -130.4668f, -130.4668f, -130.4668f, -130.4668f, 
     -575.2308f, -575.2308f, -575.2308f, -575.2308f, -575.2308f, -575.2308f, -575.2308f, -575.2308f, 
     -575.2308f, -575.2308f, -575.2308f, -575.2308f, -575.2308f, -575.2308f, -575.2308f, -575.2308f, 
     -575.2308f, -575.2308f, -575.2308f, -575.2308f, -575.2308f, -575.2308f, -575.2308f, -575.2308f},
    {-134.3803f, -134.3803f, -134.3803f, -134.3803f, -134.3803f, -134.3803f, -134.3803f, -134.3803f, 
     -571.2227f, -571.2227f, -571.2227f, -571.2227f, -571.2227f, -571.2227f, -571.2227f, -571.2227f, 
     -571.2227f, -571.2227f, -571.2227f, -571.2227f, -571.2227f, -571.2227f, -571.2227f, -571.2227f, 
     -571.2227f, -571.2227f, -571.2227f, -571.2227f, -571.2227f, -571.2227f, -571.2227f, -571.2227f},
    {-137.3661f, -137.3661f, -137.3661f, -137.3661f, -137.3661f, -137.3661f, -137.3661f, -567.0271f, 
     -567.0271f, -567.0271f, -567.0271f, -567.0271f, -567.0271f, -567.0271f, -567.0271f, -567.0271f, 
     -567.0271f, -567.0271f, -567.0271f, -567.0271f, -567.0271f, -567.0271f, -567.0271f, -567.0271f, 
     -567.0271f, -567.0271f, -567.0271f, -567.0271f, -567.0271f, -567.0271f, -567.0271f, -567.0271f},
    {-140.7241f, -140.7241f, -140.7241f, -140.7241f, -140.7241f, -140.7241f, -140.7241f, -562.6742f, 
     -562.6742f, -562.6742f, -562.6742f, -562.6742f, -562.6742f, -562.6742f, -562.6742f, -562.6742f, 
     -562.6742f, -562.6742f, -562.6742f, -562.6742f, -562.6742f, -562.6742f, -562.6742f, -562.6742f, 
     -562.6742f, -562.6742f, -562.6742f, -562.6742f, -562.6742f, -562.6742f, -562.6742f, -562.6742f},
    {-144.0252f, -144.0252f, -144.0252f, -144.0252f, -144.0252f, -144.0252f, -144.0252f, -558.1985f, 
     -558.1985f, -558.1985f, -558.1985f, -558.1985f, -558.1985f, -558.1985f, -558.1985f, -558.1985f, 
     -558.1985f, -558.1985f, -558.1985f, -558.1985f, -558.1985f, -558.1985f, -558.1985f, -558.1985f, 
     -558.1985f, -558.1985f, -558.1985f, -558.1985f, -558.1985f, -558.1985f, -558.1985f, -558.1985f},
    {-147.2721f, -147.2721f, -147.2721f, -147.2721f, -147.2721f, -147.2721f, -147.2721f, -553.6386f, 
     -553.6386f, -553.6386f, -553.6386f, -553.6386f, -553.6386f, -553.6386f, -553.6386f, -553.6386f, 
     -553.6386f, -553.6386f, -553.6386f, -553.6386f, -553.6386f, -553.6386f, -553.6386f, -553.6386f, 
     -553.6386f, -553.6386f, -553.6386f, -553.6386f, -553.6386f, -553.6386f, -553.6386f, -553.6386f},
    {-150.4676f, -150.4676f, -150.4676f, -150.4676f, -150.4676f, -150.4676f, -150.4676f, -549.0324f, 
     -549.0324f, -549.0324f, -549.0324f, -549.0324f, -549.0324f, -549.0324f, -549.0324f, -549.0324f, 
     -549.0324f, -549.0324f, -549.0324f, -549.0324f, -549.0324f, -549.0324f, -549.0324f, -549.0324f, 
     -549.0324f, -549.0324f, -549.0324f, -549.0324f, -549.0324f, -549.0324f, -549.0324f, -549.0324f},
    {-153.6138f, -153.6138f, -153.6138f, -153.6138f, -153.6138f, -153.6138f, -153.6138f, -544.4238f, 
     -544.4238f, -544.4238f, -544.4238f, -544.4238f, -544.4238f, -544.4238f, -544.4238f, -544.4238f, 
     -544.4238f, -544.4238f, -544.4238f, -544.4238f, -544.4238f, -544.4238f, -544.4238f, -544.4238f, 
     -544.4238f, -544.4238f, -544.4238f, -544.4238f, -544.4238f, -544.4238f, -544.4238f, -544.4238f}
};

/* (转矩 Nm, 转速 rpm) 双线性查表 -> Id (A) */
float Lookup_Id(float torque, float speed)
{
    int t_idx, s_idx;
    float t_ratio, s_ratio;
    float v0, v1, v2, v3;

    /* 转矩索引(按有效尺寸) */
    if (torque <= Torque_Table[0]) { t_idx = 0; t_ratio = 0.0f; }
    else if (torque >= Torque_Table[g_map_tq_pts-1]) { t_idx = g_map_tq_pts - 2; t_ratio = 1.0f; }
    else { float ts = Torque_Table[1]-Torque_Table[0]; t_idx = (int)((torque-Torque_Table[0])/ts); t_ratio = (torque-Torque_Table[t_idx])/ts; }

    /* 转速索引(按有效尺寸) */
    if (speed <= Speed_Table[0]) { s_idx = 0; s_ratio = 0.0f; }
    else if (speed >= Speed_Table[g_map_spd_pts-1]) { s_idx = g_map_spd_pts - 2; s_ratio = 1.0f; }
    else { float ss = Speed_Table[1]-Speed_Table[0]; s_idx = (int)((speed-Speed_Table[0])/ss); s_ratio = (speed-Speed_Table[s_idx])/ss; }
    /* 越界防护 */
    if(t_idx>g_map_tq_pts-2)
        t_idx=g_map_tq_pts-2;
    else if(t_idx<0)
        t_idx=0;
    if(s_idx>g_map_spd_pts-2)
        s_idx=g_map_spd_pts-2;
    else if(s_idx<0)
        s_idx=0;
    /* 双线性插值 */
    v0 = Id_Map[t_idx][s_idx];
    v1 = Id_Map[t_idx][s_idx+1];
    v2 = Id_Map[t_idx+1][s_idx];
    v3 = Id_Map[t_idx+1][s_idx+1];

    return v0*(1-t_ratio)*(1-s_ratio) + v1*(1-t_ratio)*s_ratio
         + v2*t_ratio*(1-s_ratio)     + v3*t_ratio*s_ratio;
}

/* **************************************************************** */
/*  Rs 温度补偿 1D 表 */
#define RS_TEMP_POINTS   10
float Rs_Temp_Table[RS_TEMP_POINTS] = {-20.0f,2.2f,24.4f,46.7f,68.9f,91.1f,113.3f,135.6f,157.8f,
    180.0f};
float Rs_Value_Table[RS_TEMP_POINTS] = {6.5852f,7.2839f,7.9825f,8.6812f,9.3799f,10.0785f,10.7772f,11.4759f,12.1745f,
    12.8732f}; /* mOhm */

float Lookup_Rs(float temp_C) {
    if (temp_C <= Rs_Temp_Table[0]) return Rs_Value_Table[0];
    if (temp_C >= Rs_Temp_Table[g_map_rs_pts-1]) return Rs_Value_Table[g_map_rs_pts-1];
    float step = Rs_Temp_Table[1]-Rs_Temp_Table[0];
    int idx = (int)((temp_C-Rs_Temp_Table[0])/step);
    /* 越界防护 */
    if(idx>g_map_rs_pts-2)
        idx=RS_TEMP_POINTS-2;
    else if(idx<0)
        idx=0;
    float r = (temp_C-Rs_Temp_Table[idx])/step;
    return Rs_Value_Table[idx]*(1-r) + Rs_Value_Table[idx+1]*r;
}

/*  Psi 温度补偿 1D 表 */
#define PSI_TEMP_POINTS  10
float Psi_Temp_Table[PSI_TEMP_POINTS] = {-20.0f,2.2f,24.4f,46.7f,68.9f,91.1f,113.3f,135.6f,157.8f,
    180.0f};
float Psi_Value_Table[PSI_TEMP_POINTS] = {17.4633f,17.0214f,16.5796f,16.1378f,15.6959f,15.2541f,14.8123f,14.3705f,13.9286f,
    13.4868f}; /* mWb */

float Lookup_Psi(float temp_C) {
    if (temp_C <= Psi_Temp_Table[0]) return Psi_Value_Table[0];
    if (temp_C >= Psi_Temp_Table[g_map_psi_pts-1]) return Psi_Value_Table[g_map_psi_pts-1];
    float step = Psi_Temp_Table[1]-Psi_Temp_Table[0];
    int idx = (int)((temp_C-Psi_Temp_Table[0])/step);
        /* 越界防护 */
    if(idx>g_map_psi_pts-2)
        idx=PSI_TEMP_POINTS-2;
    else if(idx<0)
        idx=0;
    float r = (temp_C-Psi_Temp_Table[idx])/step;
    return Psi_Value_Table[idx]*(1-r) + Psi_Value_Table[idx+1]*r;
}

///*  Ld 饱和 2D 表 (Froelich) [Id_idx][Iq_idx]  uH */
//#define LD_SAT_ID_PTS    6
//#define LD_SAT_IQ_PTS    6
//const float Ld_Id_Axis[LD_SAT_ID_PTS] = {-600.0f,-480.0f,-360.0f,-240.0f,-120.0f,0.0f}; /* A */
//const float Ld_Iq_Axis[LD_SAT_IQ_PTS] = {0.0f,120.0f,240.0f,360.0f,480.0f,600.0f}; /* A */
//const float Ld_Sat_Map[LD_SAT_ID_PTS][LD_SAT_IQ_PTS] = {
//    {48.10f,47.32f,45.14f,41.91f,38.10f,34.12f},
//    {56.42f,55.36f,52.39f,48.10f,43.15f,38.10f},
//    {65.20f,63.78f,59.88f,54.33f,48.10f,41.91f},
//    {73.35f,71.56f,66.68f,59.88f,52.39f,45.14f},
//    {79.30f,77.21f,71.56f,63.78f,55.36f,47.32f},
//    {81.50f,79.30f,73.35f,65.20f,56.42f,48.10f}
//}; /* uH */

///*  Lq 饱和 2D 表 (Froelich) [Id_idx][Iq_idx]  uH */
//#define LQ_SAT_ID_PTS    6
//#define LQ_SAT_IQ_PTS    6
//const float Lq_Id_Axis[LQ_SAT_ID_PTS] = {-600.0f,-480.0f,-360.0f,-240.0f,-120.0f,0.0f}; /* A */
//const float Lq_Iq_Axis[LQ_SAT_IQ_PTS] = {0.0f,120.0f,240.0f,360.0f,480.0f,600.0f}; /* A */
//const float Lq_Sat_Map[LQ_SAT_ID_PTS][LQ_SAT_IQ_PTS] = {
//    {71.61f,69.90f,65.24f,58.72f,51.51f,44.48f},
//    {91.75f,88.97f,81.56f,71.61f,61.17f,51.51f},
//    {117.44f,112.92f,101.24f,86.35f,71.61f,58.72f},
//    {146.80f,139.81f,122.33f,101.24f,81.56f,65.24f},
//    {172.71f,163.11f,139.81f,112.92f,88.97f,69.90f},
//    {183.50f,172.71f,146.80f,117.44f,91.75f,71.61f}
//}; /* uH */

/*  Ld 饱和 2D 表 (Froelich) [Id_idx][Iq_idx]  uH */
#define LD_SAT_ID_PTS    6
#define LD_SAT_IQ_PTS    6
float Ld_Id_Axis[LD_SAT_ID_PTS] = {-600.0f,-480.0f,-360.0f,-240.0f,-120.0f,0.0f}; /* A */
float Ld_Iq_Axis[LD_SAT_IQ_PTS] = {0.0f,120.0f,240.0f,360.0f,480.0f,600.0f}; /* A */
//float Ld_Sat_Map[LD_SAT_ID_PTS][LD_SAT_IQ_PTS] = {
//    {74.79f,73.59f,70.19f,65.18f,59.25f,53.05f},
//    {87.74f,86.08f,81.47f,74.79f,67.09f,59.25f},
//    {101.38f,99.18f,93.11f,84.49f,74.79f,65.18f},
//    {114.06f,111.28f,103.69f,93.11f,81.47f,70.19f},
//    {123.30f,120.06f,111.28f,99.18f,86.08f,73.59f},
//    {126.73f,123.30f,114.06f,101.38f,87.74f,74.79f}
//}; /* uH */
//金宇星电机
//float Ld_Sat_Map[LD_SAT_ID_PTS][LD_SAT_IQ_PTS] = {
//    {48.78f,48.00f,45.78f,42.51f,38.65f,34.60f},
//    {57.23f,56.15f,53.14f,48.78f,43.76f,38.65f},
//    {66.13f,64.69f,60.73f,55.11f,48.78f,42.51f},
//    {74.39f,72.58f,67.63f,60.73f,53.14f,45.78f},
//    {80.43f,78.31f,72.58f,64.69f,56.15f,48.00f},
//    {82.66f,80.43f,74.39f,66.13f,57.23f,48.78f}
//}; /* uH */
//float Ld_Sat_Map[LD_SAT_ID_PTS][LD_SAT_IQ_PTS] = {
//    {24.31f,23.92f,22.82f,21.19f,19.26f,17.25f},
//    {28.52f,27.98f,26.49f,24.31f,21.81f,19.26f},
//    {32.96f,32.24f,30.27f,27.47f,24.31f,21.19f},
//    {37.08f,36.18f,33.71f,30.27f,26.49f,22.82f},
//    {40.09f,39.03f,36.18f,32.24f,27.98f,23.92f},
//    {41.20f,40.09f,37.08f,32.96f,28.52f,24.31f}
//}; /* uH */
//新伟中置电机
float Ld_Sat_Map[LD_SAT_ID_PTS][LD_SAT_IQ_PTS] = {
    {20.86f,20.53f,19.58f,18.18f,16.53f,14.80f},
    {24.47f,24.01f,22.73f,20.86f,18.71f,16.53f},
    {28.28f,27.67f,25.97f,23.57f,20.86f,18.18f},
    {31.81f,31.04f,28.92f,25.97f,22.73f,19.58f},
    {34.39f,33.49f,31.04f,27.67f,24.01f,20.53f},
    {35.35f,34.39f,31.81f,28.28f,24.47f,20.86f}
}; /* uH */

/*  Lq 饱和 2D 表 (Froelich) [Id_idx][Iq_idx]  uH */
#define LQ_SAT_ID_PTS    6
#define LQ_SAT_IQ_PTS    6
float Lq_Id_Axis[LQ_SAT_ID_PTS] = {-600.0f,-480.0f,-360.0f,-240.0f,-120.0f,0.0f}; /* A */
float Lq_Iq_Axis[LQ_SAT_IQ_PTS] = {0.0f,120.0f,240.0f,360.0f,480.0f,600.0f}; /* A */
//float Lq_Sat_Map[LQ_SAT_ID_PTS][LQ_SAT_IQ_PTS] = {
//    {109.28f,106.68f,99.57f,89.61f,78.60f,67.89f},
//    {140.01f,135.77f,124.46f,109.28f,93.34f,78.60f},
//    {179.22f,172.33f,154.50f,131.78f,109.28f,89.61f},
//    {224.02f,213.36f,186.69f,154.50f,124.46f,99.57f},
//    {263.56f,248.92f,213.36f,172.33f,135.77f,106.68f},
//    {280.03f,263.56f,224.02f,179.22f,140.01f,109.28f}
//}; /* uH */
//金宇星电机
//float Lq_Sat_Map[LQ_SAT_ID_PTS][LQ_SAT_IQ_PTS] = {
//    {69.64f,67.98f,63.45f,57.10f,50.09f,43.26f},
//    {89.22f,86.52f,79.31f,69.64f,59.48f,50.09f},
//    {114.21f,109.82f,98.46f,83.98f,69.64f,57.10f},
//    {142.76f,135.96f,118.97f,98.46f,79.31f,63.45f},
//    {167.95f,158.62f,135.96f,109.82f,86.52f,67.98f},
//    {178.45f,167.95f,142.76f,114.21f,89.22f,69.64f}
//}; /* uH */
//float Lq_Sat_Map[LQ_SAT_ID_PTS][LQ_SAT_IQ_PTS] = {
//    {38.28f,37.37f,34.88f,31.39f,27.54f,23.78f},
//    {49.05f,47.56f,43.60f,38.28f,32.70f,27.54f},
//    {62.78f,60.37f,54.12f,46.16f,38.28f,31.39f},
//    {78.48f,74.74f,65.40f,54.12f,43.60f,34.88f},
//    {92.33f,87.20f,74.74f,60.37f,47.56f,37.37f},
//    {98.10f,92.33f,78.48f,62.78f,49.05f,38.28f}
//}; /* uH */
//新伟中置电机
//float Lq_Sat_Map[LQ_SAT_ID_PTS][LQ_SAT_IQ_PTS] = {
//    {17.51f,17.09f,15.95f,14.36f,12.59f,10.88f},
//    {22.43f,21.75f,19.94f,17.51f,14.95f,12.59f},
//    {28.71f,27.61f,24.75f,21.11f,17.51f,14.36f},
//    {35.89f,34.18f,29.91f,24.75f,19.94f,15.95f},
//    {42.22f,39.88f,34.18f,27.61f,21.75f,17.09f},
//    {44.86f,42.22f,35.89f,28.71f,22.43f,17.51f}
//}; /* uH */
float Lq_Sat_Map[LQ_SAT_ID_PTS][LQ_SAT_IQ_PTS] = {
    {30.47f,29.74f,27.76f,24.98f,21.91f,18.93f},
    {39.03f,37.85f,34.70f,30.47f,26.02f,21.91f},
    {49.96f,48.04f,43.07f,36.74f,30.47f,24.98f},
    {62.46f,59.48f,52.05f,43.07f,34.70f,27.76f},
    {73.48f,69.40f,59.48f,48.04f,37.85f,29.74f},
    {78.07f,73.48f,62.46f,49.96f,39.03f,30.47f}
}; /* uH */
/* 标定表运行状态与量程变量 (表本体即上方数组, 上电由 C 初始值装载, 无需初始化调用)
   值表(0x21/02/03)紧致编址: idx = 扭矩行*转速有效点数 + 转速列。 */
uint8_t g_map_rw_status = 0x01U;   /* 0x21/01: 0x01成功 0x02索引超范围 0x03数据超范围 */
uint8_t g_map_tq_pts    = TORQUE_POINTS;   /* MTPA 有效行数(扭矩): 3..32 */
uint8_t g_map_spd_pts   = SPEED_POINTS;    /* MTPA 有效列数(转速): 3..32 */
float   g_map_tq_max    = 50.0F;           /* 扭矩满量程 N.m (0x20/03 idx0) */
float   g_map_spd_max   = 8000.0F;         /* 转速满量程 rpm (0x20/03 idx0) */

/* 值表(0x02/0x03)紧致编址: idx = 扭矩行*当前转速点数 + 转速列 —— 尺寸变化后仍连续;
   底层存储仍按满 32 步长, 这里做 行列->存储位置 换算与有效矩阵边界检查 */
static float *MapStore_Cell(uint8_t sub, uint16_t idx, float *s)
{
    if ((sub == 0x10U) || (sub == 0x11U)) {
        uint16_t r_ = (uint16_t)(idx / g_map_ld_iq_pts);
        uint16_t c_ = (uint16_t)(idx % g_map_ld_iq_pts);
        if ((r_ >= g_map_ld_id_pts) || (c_ >= g_map_ld_iq_pts)) { return 0; }
        return &s[(uint16_t)((uint16_t)r_ * LD_SAT_IQ_PTS) + c_];
    }
    if ((sub == 0x02U) || (sub == 0x03U)) {
        uint16_t r_ = (uint16_t)(idx / g_map_spd_pts);
        uint16_t c_ = (uint16_t)(idx % g_map_spd_pts);
        if ((r_ >= g_map_tq_pts) || (c_ >= g_map_spd_pts)) { return 0; }
        return &s[(uint16_t)((uint16_t)r_ * SPEED_POINTS) + c_];
    }
    return &s[idx];
}

/* 标定表读写 (协议 0x21): sub 与数组编号对齐; 索引=数组下标, 越界/非法值返回状态码。
   返回: 0x01 成功 / 0x02 索引超范围 / 0x03 写入数据超范围。 */
static float *MapStore_Slot(uint8_t sub, uint16_t idx, uint16_t *limit)
{
    *limit = 0U;
    switch (sub) {
    case 0x02U: *limit = (uint16_t)g_map_tq_pts * g_map_spd_pts; return &Id_Map[0][0];   /* MTPA-D轴电流参考(紧致) */
    case 0x03U: *limit = (uint16_t)g_map_tq_pts * g_map_spd_pts; return &Iq_Map[0][0];   /* MTPA-Q轴电流参考(紧致) */
    case 0x04U: *limit = g_map_spd_pts;  return &Speed_Table[0];  /* X轴: 转速(有效长度) */
    case 0x05U: *limit = g_map_tq_pts;  return &Torque_Table[0]; /* Y轴: 扭矩(有效长度) */
    case 0x06U: *limit = g_map_rs_pts;  return &Rs_Temp_Table[0];   /* Temp(Rs) */
    case 0x07U: *limit = g_map_rs_pts;  return &Rs_Value_Table[0];    /* Rs 值 */
    case 0x08U: *limit = g_map_psi_pts; return &Psi_Temp_Table[0];  /* Temp(Phi) */
    case 0x09U: *limit = g_map_psi_pts; return &Psi_Value_Table[0];   /* Phi 值 */
    case 0x10U: *limit = (uint16_t)g_map_ld_id_pts * g_map_ld_iq_pts; return &Ld_Sat_Map[0][0];   /* Ld 值表 */
    case 0x11U: *limit = (uint16_t)g_map_ld_id_pts * g_map_ld_iq_pts; return &Lq_Sat_Map[0][0];   /* Lq 值表 */
    case 0x12U: *limit = g_map_ld_id_pts; return &Ld_Id_Axis[0];  /* Ld/Lq 表-D轴(Id)参考 */
    case 0x13U: *limit = g_map_ld_iq_pts; return &Ld_Iq_Axis[0];  /* Ld/Lq 表-Q轴(Iq)参考 */
    default: return 0;
    }
}

/* 前置声明: 定义在本文件末尾(轴保护辅助) */
static uint8_t MapStore_IsAxisSub(uint8_t sub);
static uint8_t MapStore_AxisOK(const float *a, uint16_t n);

uint8_t MapStore_Read(uint8_t sub, uint16_t idx, float *v)
{
    uint16_t lim;
    float *s = MapStore_Slot(sub, idx, &lim);
    float *e;
    if ((s == 0) || (idx >= lim) || (v == 0)) { g_map_rw_status = 0x02U; return 0U; }
    e = MapStore_Cell(sub, idx, s);
    if (e == 0) { g_map_rw_status = 0x02U; return 0U; }   /* 值表越出有效矩阵 */
    *v = *e;
    g_map_rw_status = 0x01U;
    return 1U;
}

uint8_t MapStore_Write(uint8_t sub, uint16_t idx, float v)
{
    uint16_t lim;
    float *s = MapStore_Slot(sub, idx, &lim);
    float *e;
    if ((s == 0) || (idx >= lim)) { g_map_rw_status = 0x02U; return 0U; }
    if (!(v >= -1.0e6F) || !(v <= 1.0e6F)) { g_map_rw_status = 0x03U; return 0U; }  /* 含 NaN */
    e = MapStore_Cell(sub, idx, s);
    if (e == 0) { g_map_rw_status = 0x02U; return 0U; }   /* 值表越出有效矩阵 */
    if (MapStore_IsAxisSub(sub) != 0U) {
        float old = *e;
        *e = v;
        {   /* 轴长度 = 本次可写元素个数 */
            uint16_t n = lim;
            if (MapStore_AxisOK(s, n) == 0U) {
                *e = old;                       /* 破坏等间隔: 回滚 */
                g_map_rw_status = 0x03U;
                return 0U;
            }
        }
    } else {
        *e = v;
    }
    g_map_rw_status = 0x01U;
    /* 注意: 这里**不得**重算轴向表 —— 否则写完轴向值再写任一表格元素, 轴向会被覆盖回等间隔
       默认值(上位机表现为"改了这个那个又复原")。轴向重算只在显式写"间隔"(协议 0x20/03
       idx0/idx1) 时由 canopen 侧调用 MapStore_RebuildAxis()。 */
    return 1U;
}

/* 矩阵信息 (协议 0x20/03): 间隔(N.m / 1rpm) -> 等间隔轴向表; 最大值由 (点数-1)*间隔 派生 */
float g_map_torque_step = 1.612903F;   /* 扭矩间隔 N.m (0x20/03 idx1 只读) = 50/31 */
float g_map_speed_step  = 258.064516F; /* 转速间隔 rpm (0x20/03 idx1 只读) = 8000/31 */
void MapStore_RebuildAxis(void)
{
    uint16_t i;
    if (g_map_torque_step <= 0.0F) {
        g_map_torque_step = (TORQUE_POINTS > 1U) ? (g_map_tq_max / (float)(TORQUE_POINTS-1)) : 1.0F;
    }
    if (g_map_speed_step <= 0.0F) {
        g_map_speed_step = (SPEED_POINTS > 1U) ? (g_map_spd_max / (float)(SPEED_POINTS-1)) : 1.0F;
    }
    for (i = 0U; i < TORQUE_POINTS; i++) { Torque_Table[i] = (float)i * g_map_torque_step; }
    for (i = 0U; i < SPEED_POINTS;  i++) { Speed_Table[i]  = (float)i * g_map_speed_step;  }
}

/* 设置 MTPA 有效尺寸(3..32): 保住当前量程不变, 间隔按新点数重排后重建等间隔轴。
   越出有效矩阵的数据不清除(镜像仍按满 32 存), 尺寸放大后原数据自动回到有效区 */
uint8_t MapStore_SetSize(uint8_t tq_pts, uint8_t spd_pts)
{
    float tmax, smax;
    if ((tq_pts < 3U) || (tq_pts > (uint8_t)TORQUE_POINTS) ||
        (spd_pts < 3U) || (spd_pts > (uint8_t)SPEED_POINTS)) {
        g_map_rw_status = 0x02U;
        return 0U;
    }


    tmax = g_map_tq_max;
    smax = g_map_spd_max;
    g_map_tq_pts  = tq_pts;
    g_map_spd_pts = spd_pts;
    g_map_torque_step = tmax / (float)(tq_pts - 1U);
    g_map_speed_step  = smax / (float)(spd_pts - 1U);
    MapStore_RebuildAxis();
    g_map_rw_status = 0x01U;
    return 1U;
}

/* Rs/磁链温度表有效点数(3..10)与 Ld/Lq 饱和表有效尺寸(3..6 x 3..6, 两表共用轴):
   只改读写窗口, 轴与数据不动, 上电回满 */
uint8_t g_map_rs_pts   = RS_TEMP_POINTS;
uint8_t g_map_psi_pts  = PSI_TEMP_POINTS;
uint8_t g_map_ld_id_pts = LD_SAT_ID_PTS;
uint8_t g_map_ld_iq_pts = LD_SAT_IQ_PTS;

uint8_t MapStore_SetAuxSize(uint8_t rs_pts, uint8_t psi_pts)
{
    if ((rs_pts < 3U) || (rs_pts > (uint8_t)RS_TEMP_POINTS) ||
        (psi_pts < 3U) || (psi_pts > (uint8_t)PSI_TEMP_POINTS)) {
        g_map_rw_status = 0x02U;
        return 0U;
    }
    {   /* 先按旧有效窗口取量程, 再改尺寸重排温度轴(与 MTPA SetSize 同口径) */
        float r0 = Rs_Temp_Table[0];
        float r1 = Rs_Temp_Table[g_map_rs_pts - 1U];
        float p0 = Psi_Temp_Table[0];
        float p1 = Psi_Temp_Table[g_map_psi_pts - 1U];
        int i;
        float sr = (r1 - r0) / (float)(rs_pts - 1U);
        float sp = (p1 - p0) / (float)(psi_pts - 1U);
        for (i = 0; i < RS_TEMP_POINTS; i++)  { Rs_Temp_Table[i]  = r0 + (float)i * sr; }
        for (i = 0; i < PSI_TEMP_POINTS; i++) { Psi_Temp_Table[i] = p0 + (float)i * sp; }
    }
    g_map_rs_pts  = rs_pts;
    g_map_psi_pts = psi_pts;

    g_map_rw_status = 0x01U;
    return 1U;
}

uint8_t MapStore_SetLdSize(uint8_t id_pts, uint8_t iq_pts)
{
    if ((id_pts < 3U) || (id_pts > (uint8_t)LD_SAT_ID_PTS) ||
        (iq_pts < 3U) || (iq_pts > (uint8_t)LD_SAT_IQ_PTS)) {
        g_map_rw_status = 0x02U;
        return 0U;
    }
    {   /* 先按旧有效窗口取量程, 再改尺寸重排轴(Id: -量程..0, Iq: 0..量程, N-1 等分) */
        float id_top = -Ld_Id_Axis[0];
        float iq_top = Ld_Iq_Axis[g_map_ld_iq_pts - 1U];
        float si = id_top / (float)(id_pts - 1U);
        float sq = iq_top / (float)(iq_pts - 1U);
        int i;
        for (i = 0; i < LD_SAT_ID_PTS; i++) {
            Ld_Id_Axis[i] = (i < (int)(id_pts - 1U)) ? (-((float)(id_pts - 1U - i) * si)) : 0.0F;
            Lq_Id_Axis[i] = Ld_Id_Axis[i];
        }
        for (i = 0; i < LD_SAT_IQ_PTS; i++) {
            Ld_Iq_Axis[i] = (float)i * sq;
            Lq_Iq_Axis[i] = Ld_Iq_Axis[i];
        }
    }
    g_map_ld_id_pts = id_pts;
    g_map_ld_iq_pts = iq_pts;
    g_map_rw_status = 0x01U;
    return 1U;
}

/* 轴向表写保护: 查表按"等间隔"算下标(step = 轴[1]-轴[0]), 轴被写成非等间隔会让索引算错。
   故轴向表的写入必须保持"严格递增且步长一致", 否则回滚并置状态 0x03。 */
static uint8_t MapStore_IsAxisSub(uint8_t sub)
{
    return ((sub == 0x04U) || (sub == 0x05U) ||   /* MTPA X轴(转速) / Y轴(扭矩) */
            (sub == 0x06U) || (sub == 0x08U) ||   /* Temp(Rs) / Temp(Phi) */
            (sub == 0x0CU) || (sub == 0x0DU)) ? 1U : 0U;   /* Ld/Lq 表 D/Q 轴 */
}

static uint8_t MapStore_AxisOK(const float *a, uint16_t n)
{
    uint16_t i;
    float d0, d;
    if ((a == 0) || (n < 2U)) { return 1U; }
    d0 = a[1] - a[0];
    if (!(d0 > 0.0F)) { return 0U; }            /* 必须递增 */
    for (i = 1U; i + 1U < n; i++) {
        d = a[i + 1U] - a[i];
        if (!(d > 0.0F)) { return 0U; }
        if (((d > d0) ? (d - d0) : (d0 - d)) > (d0 * 1.0e-3F)) { return 0U; }   /* 步长一致 */
    }
    return 1U;
}

/* Ld/Lq 饱和表 2D 双线性查表 (uH)。轴向表等间隔(120A), 索引按区间定位,
   轴外值钳位到边界点。Id 轴 [-600..0]A, Iq 轴 [0..600]A;
   制动 Id>0 超出 Id 轴 -> 钳到 0A 列 (=不饱和标称值), 合理回退。 */
static int Map_AxisIdx(float v, const float *axis, int n, float *ratio)
{
    float step = axis[1] - axis[0];
    float f;
    int   idx;

    if (!(step > 0.0F)) { *ratio = 0.0F; return 0; }   /* 含 step=NaN 防护 */
    f = (v - axis[0]) / step;
    if (!(f > 0.0F))              { idx = 0;     *ratio = 0.0F; }
    else if (f >= (float)(n - 1)) { idx = n - 2; *ratio = 1.0F; }
    else                          { idx = (int)f; *ratio = f - (float)idx; }
    return idx;
}

float Lookup_Ld(float id_a, float iq_a)
{
    float ri, rj;
    int   i, j;
    float v0, v1, v2, v3;

    i = Map_AxisIdx(id_a, Ld_Id_Axis, g_map_ld_id_pts, &ri);
    j = Map_AxisIdx(iq_a, Ld_Iq_Axis, g_map_ld_iq_pts, &rj);
    v0 = Ld_Sat_Map[i][j];     v1 = Ld_Sat_Map[i][j + 1];
    v2 = Ld_Sat_Map[i + 1][j]; v3 = Ld_Sat_Map[i + 1][j + 1];
    return v0 * (1.0F - ri) * (1.0F - rj) + v1 * (1.0F - ri) * rj
         + v2 * ri * (1.0F - rj)         + v3 * ri * rj;
}

float Lookup_Lq(float id_a, float iq_a)
{
    float ri, rj;
    int   i, j;
    float v0, v1, v2, v3;

    i = Map_AxisIdx(id_a, Lq_Id_Axis, g_map_ld_id_pts, &ri);
    j = Map_AxisIdx(iq_a, Lq_Iq_Axis, g_map_ld_iq_pts, &rj);
    v0 = Lq_Sat_Map[i][j];     v1 = Lq_Sat_Map[i][j + 1];
    v2 = Lq_Sat_Map[i + 1][j]; v3 = Lq_Sat_Map[i + 1][j + 1];
    return v0 * (1.0F - ri) * (1.0F - rj) + v1 * (1.0F - ri) * rj
         + v2 * ri * (1.0F - rj)         + v3 * ri * rj;
}
